# Keil uVision project baboomDriver.uvprojx, settings and files
target KL25Z (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Serial-Demo
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Sources
    ./src/: main.c queue.c onboard_leds.c scheduler.c motor.c serialcomm.c
  group Headers
    ./inc/: onboard_leds.h queue.h serialcomm.h scheduler.h motor.h
software components: CMSIS:CORE 5.3.0, Device:Startup 2.5.0
